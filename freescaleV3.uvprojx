# Keil uVision project freescaleV3.uvprojx, settings and files
target MK60DN512 (ARM-ADS)
  device: MK60DN512xxx10 Freescale
  pack: Keil.Kinetis_K60_DFP.1.3.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: freescaleV3
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: MK60D10 RAVEN DEBUG,ARM_MATH_CM4
  c misc: --c99
  c include: .\app;.\base;.\CH_Lib\inc;.\sys
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group user
    ./user/: main.c code standard.txt pin configuration.txt
  group app
    ./app/: outputdata.c wxwxdatasend.c angle.c
  group base
    ./base/: led.c usart.c flash.c timer.c motor.c anglebase.c ccd.c
  group sys
    ./sys/: delay.c sys.c
  group Chlib
    ./CH_Lib/src/: adc.c common.c gpio.c systick.c uart.c
software components: CMSIS:CORE 3.40.0, CMSIS:DSP 1.4.2, Device:Startup 1.0.0
